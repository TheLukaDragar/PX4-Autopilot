## src/drivers/esc_beep/Kconfig
```kconfig
menuconfig DRIVERS_ESC_BEEP
	bool "esc_beep"
	default n
	---help---
		Enable support for esc_beep
```
